# Keil uVision project test_Gorelka_stm32f030_1.uvprojx, settings and files
target test_Gorelka_stm32f030_1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: test_Gorelka_stm32f030_1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
software components: CMSIS:CORE 4.1.0
